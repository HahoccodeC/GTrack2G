# Keil uVision project GTrackModuleTest.uvprojx, settings and files
target GTrackModuleTest (6190000::V6.19::ARMCLANG)
  device: STM32F030CCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: GTrackModuleTest
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F030xC
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../Core/Src/GTrack;../Core/Ultilities;../Core/Src/Test;../Drivers/Device_Driver/bma253_generic;../HardwareLayer;../AbstractionLayer;../Components/Libraries;../Components/Middlewares/NetworkLayer;../Components/Middlewares/UserLayer;../Drivers/Device_Driver/mc60_generic
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/User
    ../Components/Middlewares/UserLayer/: gtrack_ual.c
  group Application/Network
    ../Components/Middlewares/NetworkLayer/: gtrack_nal.c
  group Peripheral/STM32
    ../AbstractionLayer/usart/: usart_pal.c
    ../Components/Libraries/display/: display_pal.c
    ../AbstractionLayer/timer/: timer_pal.c
    ../Components/Libraries/signal/: signal_pal.c
    ../AbstractionLayer/adc/: adc_pal.c
    ../Components/Libraries/supplier/: supplier_pal.c
  group Peripheral/Devices/MC60
    ../Components/Libraries/mc60/: mc60_pal.c
  group Peripheral/Devices/BMA253
    ../Components/Libraries/bma253/: bma253_pal.c
  group Hardware/STM32
    ../HardwareLayer/gpio/: gpio_hcl.c
    ../HardwareLayer/i2c/: i2c_hcl.c
    ../HardwareLayer/usart/: fifo_hcl.c usart_hcl.c
    ../HardwareLayer/timer/: timer_hcl.c
    ../HardwareLayer/adc/: adc_hcl.c
  group Hardware/Drivers/MC60
    ../Drivers/Device_Driver/mc60_generic/gnss/parser/NMEAParser-0.1.2/src/: nmea_utility.c
    ../Drivers/Device_Driver/mc60_generic/gnss/parser/NMEAParser-0.1.2/src/core/: nmea_converter.c nmea_data.c nmea_decoder.c
    ../Drivers/Device_Driver/mc60_generic/interface/: mc60_interface.c
    ../Drivers/Device_Driver/mc60_generic/interface/utils/: mc60_util.c
    ../Drivers/Device_Driver/mc60_generic/network/mqtt/: mc60_mqtt.c
  group Hardware/Drivers/BMA253
    ../Drivers/Device_Driver/bma253_generic/: bma253_driver.c
    ../Drivers/Device_Driver/bma253_generic/hardware/: bma253_hardware_interface.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Boot
    ./: startup_stm32f030xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
software components: CMSIS:CORE 5.6.0
